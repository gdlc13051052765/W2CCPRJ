# Keil uVision project RADIO_CAN.uvprojx, settings and files
target RADIO_CAN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sl_radio +hex
  AfterMake: fromelf.exe --bin --output ./bin/w2_cc.bin ./RADIO_CAN/sl_radio.axf
  AfterMake: .\bin\mcu_tools.exe  ./../Inc/board_info.h  w2_cc.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F105xC,USE_HAL_DRIVER
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Application\inc;..\event_manage\inc;..\Hardware\inc;..\iap_boot\inc;..\uart_debug\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group application
    ../Application/src/: application.c interface.c command.c box_info.c comm_can.c config_can.c
  group iap_boot
    ../iap_boot/src/: st_flash.c ex_flash.c frame_parse.c iap_protocols.c
  group event_sig
    ../event_manage/src/: mini_dispatch.c uart_debug.c crc.c def_fifo.c can_def_fifo.c serial_def_fifo.c can_fifo.c
  group hardware
    ../Hardware/src/: bsp_init.c serial.c spi_class.c load_gpio.c led_beep.c can_drv.c st_crc.c gd25q_driver.c
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group uart_debug
    ../uart_debug/src/: debug_task.c ex_debug_func.c
software components: CMSIS:CORE 5.3.0
